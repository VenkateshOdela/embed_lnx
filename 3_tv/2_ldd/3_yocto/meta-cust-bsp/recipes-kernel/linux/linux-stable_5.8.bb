LINUX_VMAJOR = "5"
LINUX_VMINOR = "8"
LINUX_VPATCH = "14"
LINUX_SRCREV = "70b225d0a8ca1242e8a75ded86b806070ec71b2f"
LINUX_SHA256 = "ee767991808d234ad9acd17f0ba94ba7979d30c528876bee6fba337ea540f0af"

require linux-stable.inc
