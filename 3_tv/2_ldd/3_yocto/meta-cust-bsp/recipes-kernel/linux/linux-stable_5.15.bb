LINUX_VMAJOR = "5"
LINUX_VMINOR = "15"
LINUX_VPATCH = "16"
LINUX_SRCREV = "63dcc388662c3562de94d69bfa771ae4cd29b79f"
LINUX_SHA256 = "ba0a0a14e89f8212bf3effa3e3118da9939e445bab52a6544f9f98a272ff1794"

require linux-stable.inc
