LINUX_VMAJOR = "5"
LINUX_VMINOR = "16"
LINUX_VPATCH = "2"
LINUX_SRCREV = "5fd3e07fd10e79694bff69fff1d38e97b47e77f0"
LINUX_SHA256 = "09fe833a4d6304327bbe00e75ad7a2587188d1f406b3265fed11a0f8c5663b44"

require linux-stable.inc
