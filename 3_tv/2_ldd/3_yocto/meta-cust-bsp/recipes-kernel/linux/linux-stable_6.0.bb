LINUX_VMAJOR = "6"
LINUX_VMINOR = "0"
LINUX_VPATCH = "13"
LINUX_SRCREV = "843cf4765c1b76102b7e24388adb478b2ec0c3fd"
LINUX_SHA256 = "08d3118d6b755769f166de6babed54964393a7c0928029bef11bf55559a72da4"

require linux-stable.inc
